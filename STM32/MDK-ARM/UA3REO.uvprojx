# Keil uVision project UA3REO.uvprojx, settings and files
target UA3REO (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: UA3REO +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4
  c include: ../Inc;                                                                                                                                                                                                                                                      ../Drivers/STM32F4xx_HAL_Driver/Inc;                                                                                                                                                                                                                                                      ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;                                                                                                                                                                                                                                                      ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;                                                                                                                                                                                                                                                      ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: bootloader.c bootloader.h encoder.c encoder.h fft.c fft.h fpga.c fpga.h functions.c functions.h lcd.c lcd.h trx_manager.c trx_manager.h wm8731.c wm8731.h wire.c wire.h audio_processor.c audio_processor.h audio_filters.c audio_filters.h agc.c agc.h notch_filter.c notch_filter.h settings.c settings.h main.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_ll_fsmc.c stm32f4xx_hal_sram.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c
  group Drivers/CMSIS
    ..//Src/: system_stm32f4xx.c
  group LCD
    ../Src/LCD/: MA_ILI9341.c MA_ILI9341.h xpt2046_spi.c xpt2046_spi.h
software components: CMSIS:CORE 5.1.2, CMSIS:DSP 1.5.2
